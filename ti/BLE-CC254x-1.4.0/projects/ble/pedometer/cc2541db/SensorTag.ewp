# IAR project SensorTag.ewp, settings and files
configuration CC2541DK-Sensor (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=2048; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; POWER_SAVING; GAPBONDMGR_NO_SUPPORT; GAPROLE_ADVCHAN=39; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_I2C=TRUE; HAL_ADC=TRUE; HAL_SLEEP_DEBUG_LED
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo; ..\source
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541DK-Sensor-OAD-ImgA (8051)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=2048; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; POWER_SAVING; GAPBONDMGR_NO_SUPPORT; GAPROLE_ADVCHAN=39; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_I2C=TRUE; HAL_ADC=TRUE; HAL_SLEEP_DEBUG_LED
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\SensorProfile; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo; ..\..\Profiles\Oad; ..\source
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541DK-Sensor-OAD-ImgA\Exe\SensorTag"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgA.xcl
configuration CC2541DK-Sensor-OAD-ImgB (8051)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=2048; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; POWER_SAVING; GAPBONDMGR_NO_SUPPORT; GAPROLE_ADVCHAN=39; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_I2C=TRUE; HAL_ADC=TRUE; HAL_SLEEP_DEBUG_LED
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541DK-Sensor-OAD-ImgB\Exe\SensorTag"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
  group APP
    ../source/: adxl345.c fonts.c hash.c oled.c OSAL_SensorTag.c putchar.c SensorTag.c SensorTag_Main.c ssd1306.c steps.c uart.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/Config
    ../../../../Components/hal/target/CC2541ST/: hal_board_cfg.h
  group HAL/Target/Drivers
    ../../../../components/hal/target/CC2541ST/: hal_adc.c hal_crc.c hal_dma.c
    ../../../../Components/hal/target/CC2541ST/: hal_flash.c hal_i2c.c hal_interrupt.c hal_keys.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c
  group HAL/Target/Includes
    ../../../../Components/hal/target/CC2541ST/: hal_aes.h hal_dma.h hal_i2c.h hal_keys.h hal_mcu.h hal_types.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c
  group OSAL
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../source/: battserv.c devinfo.c ptprofile.c
    ../../Profiles/Roles/: gap.c peripheral.c
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/OAD/: oad_target.c
    ../../Profiles/SensorProfile/: st_util.c
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c
